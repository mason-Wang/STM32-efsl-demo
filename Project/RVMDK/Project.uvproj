# Keil uVision project Project.uvproj, settings and files
target stm32 fatfs test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fatfs_test +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress 236
  c include: ..\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_ETH_Driver\inc;..\..\Libraries\CMSIS\Core\CM3;..\..\Utilities\lwip-1.3.1\port\;..\..\Utilities\lwip-1.3.1\src\include;..\..\Utilities\lwip-1.3.1\src\include\ipv4;..\..\Utilities\lwip-1.3.1\src\include\lwip;..\..\Utilities\efsl\include;..\..\Utilities\efsl\include\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: stm32f10x_it.c main.c monitor.c stm32_uart.c
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_i2c.c
  group efsl
    ../../Utilities/efsl/source/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
    ../../Utilities/efsl/source/interface/: if_stm32.c stm32_sd.c stm32_spi.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
